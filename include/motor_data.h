/**
 * @file motor_data.h
 * @brief OpenMotor CSV → C 배열 (자동 생성)
 *
 * 두 모터 프로파일:
 *   MOTOR_SHORT — 1.6s 고추력 (311N avg, 476 N·s)
 *   MOTOR_LONG  — 3.6s 저추력 (105N avg, 386 N·s)
 *
 * 런타임 선택: motor_profile_t 구조체 + motor_get_profile()
 */

#ifndef MOTOR_DATA_H
#define MOTOR_DATA_H

#include <stdint.h>
#include <stdbool.h>

/* Note: interp1_linear() from math_utils.h must be available.
 * This is guaranteed when motor_data.h is included via config.h. */

/* ================================================================
 *  추력 프로파일 구조체
 * ================================================================ */

#define MOTOR_MAX_PTS  128  /* 최대 데이터 포인트 수 */

typedef struct {
    uint16_t n_pts;                         /* 데이터 포인트 수 */
    float t_burn;                           /* 연소 시간 (s) */
    float m_prop;                           /* 초기 추진제 질량 (kg) */
    float T_avg;                            /* 평균 추력 (N) */
    float t[MOTOR_MAX_PTS];                 /* 시간 (s) */
    float thrust[MOTOR_MAX_PTS];            /* 추력 (N) */
    float mdot[MOTOR_MAX_PTS];              /* 총 질량유량 (kg/s) */
    float prop_remaining[MOTOR_MAX_PTS];    /* 잔여 추진제 (kg) */
} motor_profile_t;

typedef enum {
    MOTOR_SELECT_SHORT = 0,   /* 1.6s 고추력 */
    MOTOR_SELECT_LONG  = 1,   /* 3.6s 저추력 */
} motor_select_t;

/* ================================================================
 *  1.6s 고추력 모터
 *  Burn: 1.53s, Prop: 457.1g, Avg: 311.3N, Peak: 482.9N, Impulse: 476.2N·s
 * ================================================================ */

#define MOTOR_SHORT_N_PTS      52
#define MOTOR_SHORT_T_BURN     1.5300f
#define MOTOR_SHORT_M_PROP     0.457110f
#define MOTOR_SHORT_T_AVG      311.2506f

static const float motor_short_time[MOTOR_SHORT_N_PTS] = {
    0.0000f, 0.0300f, 0.0600f, 0.0900f, 0.1200f, 0.1500f, 0.1800f, 0.2100f,
    0.2400f, 0.2700f, 0.3000f, 0.3300f, 0.3600f, 0.3900f, 0.4200f, 0.4500f,
    0.4800f, 0.5100f, 0.5400f, 0.5700f, 0.6000f, 0.6300f, 0.6600f, 0.6900f,
    0.7200f, 0.7500f, 0.7800f, 0.8100f, 0.8400f, 0.8700f, 0.9000f, 0.9300f,
    0.9600f, 0.9900f, 1.0200f, 1.0500f, 1.0800f, 1.1100f, 1.1400f, 1.1700f,
    1.2000f, 1.2300f, 1.2600f, 1.2900f, 1.3200f, 1.3500f, 1.3800f, 1.4100f,
    1.4400f, 1.4700f, 1.5000f, 1.5300f
};

static const float motor_short_thrust[MOTOR_SHORT_N_PTS] = {
    0.0000f, 251.3481f, 254.8929f, 258.3117f, 262.0719f, 265.7267f,
    269.3331f, 273.0578f, 276.7350f, 280.4536f, 284.0799f, 287.7356f,
    291.3861f, 295.0451f, 298.5966f, 302.1886f, 305.7770f, 309.3704f,
    312.8726f, 317.8535f, 325.4299f, 333.0464f, 340.9242f, 348.8638f,
    356.8623f, 365.1269f, 373.4956f, 382.0009f, 390.5812f, 399.2007f,
    408.0783f, 417.1056f, 426.1180f, 435.3349f, 444.6717f, 453.9980f,
    463.4872f, 473.0753f, 482.8917f, 344.6078f, 302.9585f, 284.1481f,
    267.4986f, 252.6445f, 238.3287f, 225.0035f, 212.3284f, 199.6662f,
    187.2695f, 175.0664f, 167.1331f, 0.0000f
};

static const float motor_short_mdot[MOTOR_SHORT_N_PTS] = {
    0.000000f, 0.000000f, 0.377790f, 0.377260f, 0.381210f, 0.384180f,
    0.389180f, 0.393540f, 0.399810f, 0.403000f, 0.408520f, 0.414050f,
    0.417620f, 0.423440f, 0.428810f, 0.431780f, 0.438200f, 0.444140f,
    0.447830f, 0.453300f, 0.456890f, 0.464390f, 0.475920f, 0.485060f,
    0.496250f, 0.507650f, 0.518850f, 0.529750f, 0.542250f, 0.553110f,
    0.565980f, 0.577580f, 0.590950f, 0.602970f, 0.614840f, 0.629930f,
    0.641800f, 0.655280f, 0.669280f, 0.682950f, 0.676860f, 0.487280f,
    0.417600f, 0.382190f, 0.351250f, 0.323990f, 0.298130f, 0.273400f,
    0.249650f, 0.226490f, 0.203750f, 0.181200f
};

static const float motor_short_prop[MOTOR_SHORT_N_PTS] = {
    0.457110f, 0.457110f, 0.449845f, 0.442562f, 0.435194f, 0.427757f,
    0.420220f, 0.412593f, 0.404849f, 0.397033f, 0.389110f, 0.381083f,
    0.372979f, 0.364765f, 0.356450f, 0.348068f, 0.339569f, 0.330960f,
    0.322276f, 0.313490f, 0.304630f, 0.295629f, 0.286412f, 0.277015f,
    0.267405f, 0.257580f, 0.247542f, 0.237295f, 0.226815f, 0.216125f,
    0.205196f, 0.194047f, 0.182650f, 0.171025f, 0.159175f, 0.147051f,
    0.134702f, 0.122103f, 0.109246f, 0.096137f, 0.083071f, 0.073285f,
    0.064639f, 0.056510f, 0.048834f, 0.041554f, 0.034651f, 0.028107f,
    0.021908f, 0.016046f, 0.010515f, 0.005311f
};

/* ================================================================
 *  3.6s 저추력 모터
 *  Burn: 3.69s, Prop: 371.4g, Avg: 104.7N, Peak: 131.4N, Impulse: 386.3N·s
 * ================================================================ */

#define MOTOR_LONG_N_PTS      124
#define MOTOR_LONG_T_BURN     3.6900f
#define MOTOR_LONG_M_PROP     0.371395f
#define MOTOR_LONG_T_AVG      104.6824f

static const float motor_long_time[MOTOR_LONG_N_PTS] = {
    0.0000f, 0.0300f, 0.0600f, 0.0900f, 0.1200f, 0.1500f, 0.1800f, 0.2100f,
    0.2400f, 0.2700f, 0.3000f, 0.3300f, 0.3600f, 0.3900f, 0.4200f, 0.4500f,
    0.4800f, 0.5100f, 0.5400f, 0.5700f, 0.6000f, 0.6300f, 0.6600f, 0.6900f,
    0.7200f, 0.7500f, 0.7800f, 0.8100f, 0.8400f, 0.8700f, 0.9000f, 0.9300f,
    0.9600f, 0.9900f, 1.0200f, 1.0500f, 1.0800f, 1.1100f, 1.1400f, 1.1700f,
    1.2000f, 1.2300f, 1.2600f, 1.2900f, 1.3200f, 1.3500f, 1.3800f, 1.4100f,
    1.4400f, 1.4700f, 1.5000f, 1.5300f, 1.5600f, 1.5900f, 1.6200f, 1.6500f,
    1.6800f, 1.7100f, 1.7400f, 1.7700f, 1.8000f, 1.8300f, 1.8600f, 1.8900f,
    1.9200f, 1.9500f, 1.9800f, 2.0100f, 2.0400f, 2.0700f, 2.1000f, 2.1300f,
    2.1600f, 2.1900f, 2.2200f, 2.2500f, 2.2800f, 2.3100f, 2.3400f, 2.3700f,
    2.4000f, 2.4300f, 2.4600f, 2.4900f, 2.5200f, 2.5500f, 2.5800f, 2.6100f,
    2.6400f, 2.6700f, 2.7000f, 2.7300f, 2.7600f, 2.7900f, 2.8200f, 2.8500f,
    2.8800f, 2.9100f, 2.9400f, 2.9700f, 3.0000f, 3.0300f, 3.0600f, 3.0900f,
    3.1200f, 3.1500f, 3.1800f, 3.2100f, 3.2400f, 3.2700f, 3.3000f, 3.3300f,
    3.3600f, 3.3900f, 3.4200f, 3.4500f, 3.4800f, 3.5100f, 3.5400f, 3.5700f,
    3.6000f, 3.6300f, 3.6600f, 3.6900f
};

static const float motor_long_thrust[MOTOR_LONG_N_PTS] = {
    0.0000f, 108.5682f, 108.2409f, 108.2123f, 108.2468f, 108.3730f,
    108.4471f, 108.5536f, 108.6766f, 108.8800f, 108.9875f, 109.2090f,
    109.4313f, 109.5867f, 109.7813f, 109.8968f, 110.0637f, 110.2293f,
    110.3759f, 110.5508f, 110.7678f, 110.8911f, 111.0908f, 111.2336f,
    111.3644f, 111.5607f, 111.7271f, 111.8893f, 112.0828f, 112.2126f,
    112.4133f, 112.6141f, 112.7526f, 112.8773f, 113.0523f, 113.1722f,
    113.3611f, 113.4949f, 113.6108f, 113.7547f, 113.8604f, 114.0145f,
    114.1842f, 114.2376f, 114.3561f, 114.4929f, 114.5607f, 114.7184f,
    114.8700f, 114.9719f, 115.0936f, 115.2191f, 115.2328f, 115.3144f,
    115.3639f, 115.5043f, 115.6701f, 115.7977f, 116.0055f, 116.1960f,
    116.4597f, 116.6953f, 116.9925f, 117.2701f, 117.5857f, 117.8980f,
    118.2160f, 118.5605f, 118.8951f, 119.2591f, 119.6059f, 119.9886f,
    120.3505f, 120.7367f, 121.1072f, 121.5019f, 121.8808f, 122.2832f,
    122.6586f, 123.0600f, 123.4419f, 123.8435f, 124.2267f, 124.6235f,
    125.0133f, 125.4120f, 125.7925f, 126.1909f, 126.5700f, 126.9610f,
    127.3390f, 127.7264f, 128.0986f, 128.4777f, 128.8474f, 129.2200f,
    129.5833f, 129.9481f, 130.3075f, 130.6640f, 131.0189f, 131.3660f,
    114.2274f, 94.6971f, 84.0996f, 76.2725f, 69.6877f, 64.1367f,
    59.2365f, 54.9016f, 50.9702f, 47.4562f, 43.9960f, 41.0620f,
    38.0243f, 35.4201f, 33.0030f, 30.6155f, 28.4355f, 26.3397f,
    24.4187f, 22.5934f, 20.7636f, 0.0000f
};

static const float motor_long_mdot[MOTOR_LONG_N_PTS] = {
    0.000000f, 0.000000f, 0.180110f, 0.179590f, 0.177910f, 0.175430f,
    0.173810f, 0.174920f, 0.174490f, 0.174890f, 0.174560f, 0.175050f,
    0.174960f, 0.175460f, 0.175400f, 0.175810f, 0.176430f, 0.176100f,
    0.175630f, 0.175570f, 0.176040f, 0.176280f, 0.176030f, 0.176080f,
    0.176330f, 0.176940f, 0.176790f, 0.176970f, 0.176900f, 0.177160f,
    0.177530f, 0.177370f, 0.177410f, 0.177400f, 0.177810f, 0.178290f,
    0.178590f, 0.178340f, 0.178400f, 0.178610f, 0.178630f, 0.178810f,
    0.178550f, 0.178850f, 0.179120f, 0.179180f, 0.179120f, 0.179180f,
    0.179270f, 0.179710f, 0.179750f, 0.179480f, 0.179510f, 0.179740f,
    0.179930f, 0.179990f, 0.179730f, 0.179780f, 0.180140f, 0.180360f,
    0.180430f, 0.180530f, 0.181200f, 0.181540f, 0.181810f, 0.182100f,
    0.182570f, 0.183100f, 0.183610f, 0.183770f, 0.184390f, 0.185060f,
    0.185390f, 0.185870f, 0.186250f, 0.187130f, 0.187750f, 0.188100f,
    0.188650f, 0.189390f, 0.190120f, 0.190670f, 0.190840f, 0.191400f,
    0.192310f, 0.192780f, 0.193270f, 0.193820f, 0.194590f, 0.195320f,
    0.195700f, 0.196220f, 0.196980f, 0.197540f, 0.197940f, 0.198350f,
    0.199130f, 0.199950f, 0.200400f, 0.200790f, 0.201310f, 0.201410f,
    0.203720f, 0.204420f, 0.187450f, 0.162030f, 0.140090f, 0.122330f,
    0.110390f, 0.101600f, 0.093390f, 0.086320f, 0.079980f, 0.074110f,
    0.068690f, 0.063830f, 0.059290f, 0.055020f, 0.051190f, 0.047380f,
    0.044090f, 0.040870f, 0.037880f, 0.035120f
};

static const float motor_long_prop[MOTOR_LONG_N_PTS] = {
    0.371395f, 0.371395f, 0.368240f, 0.365097f, 0.361978f, 0.358893f,
    0.355831f, 0.352749f, 0.349671f, 0.346584f, 0.343500f, 0.340406f,
    0.337311f, 0.334206f, 0.331099f, 0.327984f, 0.324857f, 0.321732f,
    0.318612f, 0.315490f, 0.312360f, 0.309223f, 0.306087f, 0.302949f,
    0.299804f, 0.296648f, 0.293492f, 0.290331f, 0.287169f, 0.284000f,
    0.280824f, 0.277649f, 0.274470f, 0.271290f, 0.268101f, 0.264903f,
    0.261698f, 0.258495f, 0.255289f, 0.252078f, 0.248865f, 0.245647f,
    0.242432f, 0.239209f, 0.235981f, 0.232751f, 0.229519f, 0.226285f,
    0.223048f, 0.219802f, 0.216554f, 0.213308f, 0.210061f, 0.206808f,
    0.203551f, 0.200291f, 0.197034f, 0.193775f, 0.190508f, 0.187237f,
    0.183963f, 0.180686f, 0.177398f, 0.174102f, 0.170801f, 0.167494f,
    0.164178f, 0.160852f, 0.157517f, 0.154178f, 0.150829f, 0.147467f,
    0.144099f, 0.140722f, 0.137338f, 0.133939f, 0.130529f, 0.127112f,
    0.123686f, 0.120246f, 0.116795f, 0.113334f, 0.109868f, 0.106393f,
    0.102903f, 0.099404f, 0.095897f, 0.092380f, 0.088850f, 0.085308f,
    0.081759f, 0.078201f, 0.074630f, 0.071050f, 0.067463f, 0.063868f,
    0.060261f, 0.056640f, 0.053011f, 0.049376f, 0.045732f, 0.042085f,
    0.038403f, 0.034710f, 0.031300f, 0.028308f, 0.025667f, 0.023309f,
    0.021146f, 0.019127f, 0.017245f, 0.015479f, 0.013820f, 0.012258f,
    0.010788f, 0.009400f, 0.008090f, 0.006853f, 0.005681f, 0.004575f,
    0.003526f, 0.002534f, 0.001594f, 0.000703f
};

/* ================================================================
 *  모터 프로파일 로드 함수
 * ================================================================ */

/**
 * @brief 선택된 모터 프로파일을 motor_profile_t에 로드.
 *
 * @param sel   MOTOR_SELECT_SHORT 또는 MOTOR_SELECT_LONG
 * @param prof  출력 구조체 (호출자가 할당)
 */
static inline void motor_load_profile(motor_select_t sel, motor_profile_t *prof)
{
    const float *src_t, *src_T, *src_mdot, *src_prop;
    uint16_t n;

    if (sel == MOTOR_SELECT_SHORT) {
        n = MOTOR_SHORT_N_PTS;
        prof->t_burn = MOTOR_SHORT_T_BURN;
        prof->m_prop = MOTOR_SHORT_M_PROP;
        prof->T_avg  = MOTOR_SHORT_T_AVG;
        src_t    = motor_short_time;
        src_T    = motor_short_thrust;
        src_mdot = motor_short_mdot;
        src_prop = motor_short_prop;
    } else {
        n = MOTOR_LONG_N_PTS;
        prof->t_burn = MOTOR_LONG_T_BURN;
        prof->m_prop = MOTOR_LONG_M_PROP;
        prof->T_avg  = MOTOR_LONG_T_AVG;
        src_t    = motor_long_time;
        src_T    = motor_long_thrust;
        src_mdot = motor_long_mdot;
        src_prop = motor_long_prop;
    }

    prof->n_pts = n;
    for (uint16_t i = 0; i < n; i++) {
        prof->t[i]              = src_t[i];
        prof->thrust[i]         = src_T[i];
        prof->mdot[i]           = src_mdot[i];
        prof->prop_remaining[i] = src_prop[i];
    }
}

/**
 * @brief 시간 t에서 추력 보간.
 *
 * @param prof   모터 프로파일
 * @param t      현재 시간 (s)
 * @return       추력 (N), 연소 후 0
 */
static inline float motor_get_thrust(const motor_profile_t *prof, float t)
{
    if (t >= prof->t[prof->n_pts - 1]) return 0.0f;
    if (t <= 0.0f) return 0.0f;
    return interp1_linear(prof->t, prof->thrust, prof->n_pts, t);
}

/**
 * @brief 시간 t에서 잔여 추진제 질량 보간.
 *
 * @param prof   모터 프로파일
 * @param t      현재 시간 (s)
 * @return       잔여 추진제 (kg), 연소 후 0
 */
static inline float motor_get_prop_remaining(const motor_profile_t *prof, float t)
{
    if (t >= prof->t[prof->n_pts - 1]) return 0.0f;
    if (t <= 0.0f) return prof->m_prop;
    return interp1_linear(prof->t, prof->prop_remaining, prof->n_pts, t);
}

#endif /* MOTOR_DATA_H */
